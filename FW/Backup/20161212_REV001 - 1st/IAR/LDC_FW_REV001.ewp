# IAR project LDC_FW_REV001.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADuCM360 AnalogDevices ADuCM360
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\AnalogDevices; $TOOLKIT_DIR$\CMSIS\Include; ..\inc\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LDC_FW_REV001.hex
  ILINK.IlinkOutputFile: LDC_FW_REV001.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: LDC_FW.c
    ../inc/: startup_ADuCM360.s
  group inc/common
    ../inc/common/: AdcLib.c ClkLib.c DacLib.c DioLib.c FeeLib.c GptLib.c I2cLib.c IntLib.c UrtLib.c WdtLib.c
  group inc/GLCD
    ../inc/GLCD/: graphic.c SPLC501C.c
  group inc/LDC
    ../inc/LDC/: LDC1612.c
  group inc/Menu
    ../inc/Menu/: Menu.c
  group inc/Utils
    ../inc/Utils/: Delay.c Flash.c
